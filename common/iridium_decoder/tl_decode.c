// TL frame body parser. See tl_decode.h for scope.
//
// Tables ported verbatim from iridium-toolkit/itl.py — three PRS_HDR
// entries (V0 = all-zeros, V1 = pre-2017, V2 = ~2017-onwards) and two
// MAP_PLANE arrays (V1 + V2) of six 256-bit signatures each.

#include "tl_decode.h"

#include <string.h>

// 16-byte PRS header signatures (V0/V1/V2). 128 bits each.
static const uint8_t PRS_HDR[3][16] = {
    // V0 — all zeros
    { 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
      0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00 },
    // V1 — pre-2017
    { 0xe7, 0xd1, 0x96, 0xe0, 0xbc, 0xac, 0x4d, 0xca,
      0x95, 0xd8, 0x5d, 0x39, 0x4c, 0x3c, 0xcb, 0x4b },
    // V2 — ~2017 onwards
    { 0xe5, 0x4d, 0x94, 0xce, 0xa9, 0x59, 0x76, 0x83,
      0xf8, 0xe8, 0x67, 0x08, 0xb8, 0xd2, 0x54, 0xcf },
};

// 32-byte plane signatures (V1). 256 bits each.
static const uint8_t MAP_PLANE_V1[6][32] = {
    { 0x67,0x4b,0x6c,0xb1,0xb8,0x52,0x34,0x1d, 0xc3,0x51,0x0b,0xe6,0xd3,0xcc,0x85,0x6a,
      0xb5,0xc0,0xb6,0xc6,0x91,0x3f,0x62,0x82, 0xb4,0xc1,0x6f,0x1c,0x72,0x5e,0x8a,0xaf },
    { 0xb8,0xd2,0x97,0x9c,0x0a,0x45,0xa7,0xe8, 0x97,0x23,0xb0,0x95,0x74,0xab,0xae,0x4d,
      0x1b,0x33,0xe9,0x1b,0x88,0x46,0xc7,0x49, 0x5d,0xf7,0x2c,0xe0,0xae,0xf4,0xf4,0x62 },
    { 0xeb,0xae,0xd8,0x65,0x72,0x9c,0xda,0xb4, 0x79,0xb0,0xaa,0x37,0x1d,0x68,0x7b,0x00,
      0xab,0x1b,0x10,0x87,0x3b,0x10,0x88,0xb9, 0x4b,0xae,0x6d,0xa2,0x44,0xfa,0x8f,0x1c },
    { 0x04,0xf4,0x94,0x92,0x54,0x1b,0x4c,0xd3, 0xe3,0x94,0xd1,0x51,0x6a,0x9d,0x9a,0xba,
      0x27,0x50,0x75,0x18,0x76,0xd1,0xdc,0xd9, 0x7c,0x16,0xda,0xcd,0x81,0xca,0x81,0xbc },
    { 0xa7,0xed,0x60,0x9b,0x6a,0xfd,0x47,0xdd, 0x52,0xde,0xfd,0x2b,0xb0,0x3d,0x38,0x95,
      0xfa,0xe7,0x0a,0x32,0x55,0x0c,0xee,0x8e, 0x57,0x65,0x12,0x3b,0x33,0x56,0x56,0xd3 },
    { 0x59,0x91,0x4d,0x0f,0xf9,0x02,0x9c,0x5c, 0xba,0xa8,0xd5,0xb6,0x40,0x97,0x51,0x5c,
      0x48,0x59,0x97,0x78,0xca,0x58,0xad,0xb8, 0xbb,0x2c,0x20,0x4e,0x9f,0x37,0x3a,0x50 },
};

// 32-byte plane signatures (V2). 256 bits each.
static const uint8_t MAP_PLANE_V2[6][32] = {
    { 0xe7,0x14,0xd3,0x14,0xfd,0x1c,0x1d,0x36, 0xb0,0xbd,0x51,0xa6,0x60,0xd4,0xc9,0x52,
      0xee,0xca,0x58,0x4c,0xdd,0x78,0x32,0xd4, 0x17,0x52,0x9c,0xa4,0xea,0x3d,0x63,0xa1 },
    { 0x9c,0xb1,0x36,0xe9,0x0f,0xe7,0xc2,0xf7, 0x60,0xa1,0x23,0xa3,0x30,0x0d,0x96,0x9d,
      0x45,0x58,0xd1,0xa2,0x8f,0x36,0x41,0x4f, 0x8e,0x6d,0x63,0x31,0xd4,0x6f,0x4c,0x27 },
    { 0xa9,0x4f,0x0e,0x49,0xe1,0x33,0x71,0x64, 0xdb,0x42,0x0c,0xc7,0xae,0x38,0x26,0xe2,
      0x34,0x9a,0x23,0x79,0xb2,0x5b,0xf5,0x48, 0x11,0xea,0xc8,0x7a,0x2f,0x8b,0x1e,0xcc },
    { 0x8c,0xb9,0xc8,0xd5,0x2a,0x2c,0xad,0x2e, 0x53,0x6f,0xc1,0x14,0x65,0x36,0xe0,0x09,
      0x3b,0x37,0x2e,0x83,0xaa,0x25,0x80,0x56, 0x1e,0xb6,0x6d,0x23,0xb3,0xc0,0xa2,0x5e },
    { 0x11,0xd3,0x17,0x04,0x97,0xfb,0x8c,0x42, 0xca,0x88,0xde,0xd8,0x5f,0xa7,0x9f,0x47,
      0xd0,0x63,0x4a,0x57,0x27,0x23,0xc8,0x84, 0xf4,0x0a,0x2d,0xea,0x14,0x90,0xe4,0xac },
    { 0x42,0x37,0xb9,0x4f,0x14,0x4e,0x64,0x38, 0x37,0x78,0x5d,0x0e,0x9c,0xa9,0x95,0xf5,
      0x33,0x68,0xe0,0x2b,0x32,0x8f,0xa3,0xc6, 0xfb,0x43,0xde,0x96,0xd0,0xe6,0xd1,0x43 },
};

// Layout helpers. After UW (24 bits = 12 symbols) and the 96-bit TL header
// (= 48 symbols) we have 384 symbols = 768 bits of body. Each symbol
// contributes one I-bit and one Q-bit; ITL version is encoded in the
// first 128 I-bits (16 bytes), plane in the next 256 I-bits (32 bytes).
#define UW_BITS                24
#define TL_HEADER_BITS         96
#define TL_BODY_OFF_BITS       (UW_BITS + TL_HEADER_BITS)   // 120 in frame->bits
#define TL_VERSION_I_BYTES     16
#define TL_PLANE_I_BYTES       32

// iridium_frame.c pair-swaps post-UW bits before classification (to align
// with iridium-toolkit's symbol-pair convention). We need the same swap
// for body extraction.
static inline uint8_t swapped_bit(const uint8_t *bits, size_t off)
{
    // For a pair (b0, b1), swapped is (b1, b0). Get the bit at the swapped
    // index: even offsets read [off+1], odd read [off-1].
    return (off & 1) ? (bits[off - 1] & 1) : (bits[off + 1] & 1);
}

// Pack `n` I-bits starting from symbol `sym_off` into `out` (MSB-first per
// byte). One I-bit per symbol → n/8 output bytes.
static void pack_i_bits(const uint8_t *post_uw, size_t sym_off,
                         size_t n, uint8_t *out)
{
    for (size_t k = 0; k < n / 8; k++) {
        uint8_t b = 0;
        for (int j = 0; j < 8; j++) {
            size_t sym = sym_off + k * 8 + j;
            // I-bit of symbol `sym` is at offset sym*2 in the swapped stream.
            b = (uint8_t)((b << 1) | swapped_bit(post_uw, sym * 2));
        }
        out[k] = b;
    }
}

void tl_decode(const iridium_frame_t *frame, tl_decoded_t *out)
{
    memset(out, 0, sizeof(*out));
    out->version = -1;
    out->plane   = -1;
    if (!frame || frame->type != IR_FRAME_TL || !frame->bits) return;

    // post_uw points at the bit after the UW: bits[24..].
    const uint8_t *post_uw = frame->bits + frame->payload_off;
    if (frame->n_bits < frame->payload_off + TL_HEADER_BITS +
        (TL_VERSION_I_BYTES + TL_PLANE_I_BYTES) * 16) {
        // ITL body is 384 symbols = 768 bits; we need at least
        // post_uw[96..96+768] available.
        return;
    }
    out->header_ok = 1;

    // Symbol offset of the start of the body (in symbols relative to post_uw).
    // 96 header bits = 48 symbols.
    size_t body_sym_off = TL_HEADER_BITS / 2;

    // Version match against PRS_HDR (16-byte signature).
    uint8_t ver_bytes[TL_VERSION_I_BYTES];
    pack_i_bits(post_uw, body_sym_off, TL_VERSION_I_BYTES * 8, ver_bytes);
    for (int v = 0; v < 3; v++) {
        if (memcmp(ver_bytes, PRS_HDR[v], TL_VERSION_I_BYTES) == 0) {
            out->version = (int8_t)v;
            break;
        }
    }
    if (out->version < 1) return;     // V0 has no plane decoding; -1 also bails

    // Plane match against MAP_PLANE for the active version.
    uint8_t plane_bytes[TL_PLANE_I_BYTES];
    pack_i_bits(post_uw, body_sym_off + TL_VERSION_I_BYTES * 8,
                TL_PLANE_I_BYTES * 8, plane_bytes);
    const uint8_t (*plane_table)[32] = (out->version == 1)
                                        ? MAP_PLANE_V1 : MAP_PLANE_V2;
    for (int p = 0; p < 6; p++) {
        if (memcmp(plane_bytes, plane_table[p], TL_PLANE_I_BYTES) == 0) {
            out->plane = (int8_t)p;
            return;
        }
    }
}
